# Keil uVision project EntranceGuard.uvprojx, settings and files
target EntranceGuard (6140001::V6.14.1::ARMCLANG)
  device: STM32L010K4Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x200007FF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: EntranceGuard +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32L010x4,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,MSI_VALUE=4194000,HSI_VALUE=16000000,LSI_VALUE=37000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1
  c include: ../Core/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;../HARDWARE/OLED;../HARDWARE/EEPROM;../HARDWARE/EINK;../HARDWARE;../HARDWARE/NFC;../HARDWARE/ACOUSTO_OPTIC;../HARDWARE/KEY;..\HARDWARE\appliactions\Inc;..\HARDWARE\interfaces\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group Application/MDK-ARM
    ./: startup_stm32l010x4.s
  group Application/User/Core
    ../HARDWARE/: font.h font.c loop.h loop.c sys.c sys.h
    ../Core/Src/: main.c gpio.c lptim.c rtc.c tim.c usart.c stm32l0xx_it.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_gpio.c stm32l0xx_ll_lptim.c stm32l0xx_ll_rcc.c stm32l0xx_ll_utils.c stm32l0xx_ll_exti.c stm32l0xx_ll_rtc.c stm32l0xx_ll_spi.c stm32l0xx_ll_dma.c stm32l0xx_ll_pwr.c stm32l0xx_ll_tim.c stm32l0xx_ll_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group HardWare/elink
    ../HARDWARE/EINK/: bmp.h eink.c eink.h
  group HardWare/eeprom
    ../HARDWARE/EEPROM/: eeprom.c eeprom.h
  group HardWare/OLED
    ../HARDWARE/OLED/: OLED.c OLED.h OLED_Font.h
    ../HARDWARE/: menu.c menu.h
  group HardWare/NFC
    ../HARDWARE/NFC/: nfc.c nfc.h
  group HardWare/ACOUSTO_OPTIC
    ../HARDWARE/ACOUSTO_OPTIC/: acousto_optic.c acousto_optic.h
  group HardWare/KEY
    ../HARDWARE/KEY/: key.c key.h
  group HardWare/interface
    ../HARDWARE/interfaces/Inc/: SI522A_interface.h
    ../HARDWARE/interfaces/Src/: SI522A_interface.c
  group HardWare/AppNFC
    ../HARDWARE/appliactions/Inc/: SI522A_App.h
    ../HARDWARE/appliactions/Src/: SI522A_App.c
software components: CMSIS:CORE 5.6.0
